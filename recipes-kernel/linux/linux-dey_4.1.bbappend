FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}-${PV}:"

LINUX_GIT_URI = "git://github.com/alexgg/linux-dey.git;protocol=http"
SRCBRANCH = "agonzal/custom"

COMPATIBLE_MACHINE = "(custom)"
